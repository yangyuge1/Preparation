# Keil uVision project hello.uvprojx, settings and files
target big_two_axis_gimbal (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: ..\Lib;..\My_lib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c
  group Lib
    ../Lib/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group My_lib
    ../My_lib/: controller.c complex_task_support.c data_structure.c my_stepper.c stepper_motor_usart_controller.c uartstdio.c connect.c yyg_jy901b.c encoder.c
    ./: my_jy901b.c two_axis_gimbal.c ZDT_X42_stepper.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
